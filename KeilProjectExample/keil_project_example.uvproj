# Keil uVision project keil_project_example.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keil_project_example +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\
  group Source Group 1
    ./: main.c
